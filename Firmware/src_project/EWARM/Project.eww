<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SW_DRV_FOR4500L.ewp</path>
  </project>
  <batchBuild />
</workspace>
